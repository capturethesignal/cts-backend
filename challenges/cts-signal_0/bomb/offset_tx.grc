<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>offset_tx</value></param>
<param><key>author</key><value>Jonathan Andersson</value></param>
<param><key>category</key><value>[RF Over IP]</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>Offset TX</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>server_address</value></param>
<param><key>value</key><value>server_address_format % (server_ip, server_port) if server_address_format != "" else ""</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>server_address_format</value></param>
<param><key>config_file</key><value>config_file</value></param>
<param><key>value</key><value>""</value></param>
<param><key>option</key><value>"server_address_format"</value></param>
<param><key>section</key><value>"main"</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>server_bw_per_port</value></param>
<param><key>config_file</key><value>config_file</value></param>
<param><key>value</key><value>1000000</value></param>
<param><key>option</key><value>"server_bw_per_port"</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>server_ip</value></param>
<param><key>config_file</key><value>config_file</value></param>
<param><key>value</key><value>""</value></param>
<param><key>option</key><value>"server_ip"</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>server_port</value></param>
<param><key>value</key><value>int(server_port_base + (tx_frequency / server_bw_per_port))</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>server_port_base</value></param>
<param><key>config_file</key><value>config_file</value></param>
<param><key>value</key><value>10000</value></param>
<param><key>option</key><value>"server_port_base"</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>zmq_tx_timeout</value></param>
<param><key>config_file</key><value>config_file</value></param>
<param><key>value</key><value>100</value></param>
<param><key>option</key><value>"zmq_tx_timeout"</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0</value></param>
<param><key>input_index</key><value>0</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>num_outputs</key><value>2</value></param>
<param><key>output_index</key><value>0 if ota == 'True' else 1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_tag_share</key>
<param><key>id</key><value>blocks_tag_share_0</value></param>
<param><key>io_type</key><value>complex</value></param>
<param><key>share_type</key><value>complex</value></param>
</block>
<block>
<key>blocks_tags_strobe</key>
<param><key>id</key><value>blocks_tags_strobe_0</value></param>
<param><key>key</key><value>pmt.intern("rx_rate")</value></param>
<param><key>nsamps</key><value>int(samp_rate)</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>value</key><value>pmt.from_double(samp_rate)</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>ignoretag</key><value>False</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>epsilon</key><value>1.0</value></param>
<param><key>freq_offset</key><value>0.0</value></param>
<param><key>noise_voltage</key><value>0.005</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>1.0 + 1.0j</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>config_file</value></param>
<param><key>label</key><value>Config File</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"signal.cfg"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>device_string</value></param>
<param><key>label</key><value>Device String</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ota</value></param>
<param><key>label</key><value>OTA</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>parent</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>Parent</value></param>
<param><key>value</key><value>self if 'self' in locals() else None</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tune_offset</value></param>
<param><key>label</key><value>Tune Offset</value></param>
<param><key>type</key><value>long</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_frequency</value></param>
<param><key>label</key><value>TX Frequency</value></param>
<param><key>type</key><value>long</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>zeromq_pub_sink</key>
<param><key>id</key><value>zeromq_pub_sink_0</value></param>
<param><key>address</key><value>server_address</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>pass_tags</key><value>True</value></param>
<param><key>timeout</key><value>zmq_tx_timeout</value></param>
</block>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_share_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tags_strobe_0</source_block_id><sink_block_id>blocks_tag_share_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>zeromq_pub_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>blocks_tag_share_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
