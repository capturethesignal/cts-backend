<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>signal</value></param>
<param><key>author</key><value>Jonathan Andersson</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>title</key><value>signal</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>config_file</value></param>
<param><key>value</key><value>"signal.cfg"</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>device_string</value></param>
<param><key>config_file</key><value>config_file</value></param>
<param><key>value</key><value>'bladerf=0,verbosity=debug,xb200=custom'</value></param>
<param><key>option</key><value>"device_string"</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>image_file_name</value></param>
<param><key>config_file</key><value>config_file</value></param>
<param><key>value</key><value></value></param>
<param><key>option</key><value>"image_file_name"</value></param>
<param><key>section</key><value>signal_name</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>image_line_repeat</value></param>
<param><key>config_file</key><value>config_file</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>"image_line_repeat"</value></param>
<param><key>section</key><value>signal_name</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>image_width</value></param>
<param><key>config_file</key><value>config_file</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>"image_width"</value></param>
<param><key>section</key><value>signal_name</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>message_font</value></param>
<param><key>config_file</key><value>config_file</value></param>
<param><key>value</key><value></value></param>
<param><key>option</key><value>"message_font"</value></param>
<param><key>section</key><value>signal_name</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>message_text</value></param>
<param><key>config_file</key><value>config_file</value></param>
<param><key>value</key><value></value></param>
<param><key>option</key><value>"message_text"</value></param>
<param><key>section</key><value>signal_name</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>ota</value></param>
<param><key>config_file</key><value>config_file</value></param>
<param><key>value</key><value>False</value></param>
<param><key>option</key><value>"ota"</value></param>
<param><key>section</key><value>signal_name</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>config_file</key><value>config_file</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>"samp_rate"</value></param>
<param><key>section</key><value>signal_name</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>signal_name</value></param>
<param><key>value</key><value>"signal"</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>tune_offset</value></param>
<param><key>config_file</key><value>config_file</value></param>
<param><key>value</key><value>19000</value></param>
<param><key>option</key><value>"tune_offset"</value></param>
<param><key>section</key><value>signal_name</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>tx_frequency</value></param>
<param><key>config_file</key><value>config_file</value></param>
<param><key>value</key><value>400000000</value></param>
<param><key>option</key><value>"tx_frequency"</value></param>
<param><key>section</key><value>signal_name</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>blocks_tag_gate</key>
<param><key>id</key><value>blocks_tag_gate_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>propagate_tags</key><value>False</value></param>
</block>
<block>
<key>epy_module</key>
<param><key>id</key><value>epy_chdir</value></param>
<param><key>source_code</key><value>
import os

script_path = os.path.dirname(os.path.realpath(__file__))
os.chdir(script_path)
</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_txt_to_image</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr
from PIL import Image, ImageDraw, ImageFont


class blk(gr.basic_block):  # sync_block):
	"""Text to Image"""

	# only default arguments here
	def __init__(self, image_file_name="", image_width=0, message_font="", message_text=""):
		"""arguments to this function show up as parameters in GRC"""
		gr.basic_block.__init__(
			self,
			name='Text to Image',   # will show up in GRC
			in_sig=[],
			out_sig=[])
		# if an attribute with the same name as a parameter is found, a callback is registered (properties work, too).
		self.image_file_name = image_file_name
		self.image_width = image_width
		self.message_font = message_font
		self.message_text = message_text
		if self.image_file_name != "":
			self.create_image()
		return

	def create_image(self):
		size = 1
		while(True):
			font = ImageFont.truetype(self.message_font, size)
			length, width = font.getsize(self.message_text)
			if width &gt; self.image_width:
				size = size - 1
				font = ImageFont.truetype(self.message_font, size)
				length, width = font.getsize(self.message_text)
				extra_length, _ = font.getsize("XX")
				length += extra_length
				break
			size += 1

		# print self.image_file_name, length, width, size

		img = Image.new('RGB', (length, self.image_width), color=(0, 0, 0))
		d = ImageDraw.Draw(img)
		d.text((0, 0), self.message_text, font=font, fill=(255, 255, 255))
		transposed = img
		transposed = transposed.transpose(Image.ROTATE_90)
		transposed = transposed.transpose(Image.FLIP_TOP_BOTTOM)
		transposed.save(self.image_file_name)
		return

	# def work(self, input_items, output_items):
	#    output_items[0][:] = input_items[0]
	#    return len(output_items[0])
</value></param>
<param><key>image_file_name</key><value>image_file_name</value></param>
<param><key>image_width</key><value>image_width</value></param>
<param><key>message_font</key><value>message_font</value></param>
<param><key>message_text</key><value>message_text</value></param>
</block>
<block>
<key>offset_tx</key>
<param><key>id</key><value>offset_tx_0</value></param>
<param><key>config_file</key><value>config_file</value></param>
<param><key>device_string</key><value>device_string</value></param>
<param><key>ota</key><value>ota</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>tx_frequency</key><value>tx_frequency</value></param>
<param><key>tune_offset</key><value>tune_offset</value></param>
</block>
<block>
<key>paint_image_source</key>
<param><key>id</key><value>paint_image_source_0</value></param>
<param><key>autocontrast</key><value>0</value></param>
<param><key>image_flip</key><value>0</value></param>
<param><key>bt709_map</key><value>0</value></param>
<param><key>image_file</key><value>image_file_name</value></param>
<param><key>image_invert</key><value>0</value></param>
<param><key>repeatmode</key><value>2</value></param>
</block>
<block>
<key>paint_paint_bc</key>
<param><key>id</key><value>paint_paint_bc_0</value></param>
<param><key>width</key><value>image_width</value></param>
<param><key>repeats</key><value>image_line_repeat</value></param>
<param><key>randomsrc</key><value>INTERNAL</value></param>
<param><key>equalization</key><value>EQUALIZATION_OFF</value></param>
</block>
<connection><source_block_id>blocks_tag_gate_0</source_block_id><sink_block_id>offset_tx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>paint_image_source_0</source_block_id><sink_block_id>paint_paint_bc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>paint_paint_bc_0</source_block_id><sink_block_id>blocks_tag_gate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
